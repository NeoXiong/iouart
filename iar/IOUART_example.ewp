# IAR project IOUART_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL03Z32xxx4 Freescale MKL03Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL03Z32VFK4; FRDM_KL03Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\../platform/osa/inc; ..\..\..\..\../platform/utilities/inc; ..\..\..\..\../platform/CMSIS/Include; ..\..\..\..\../platform/devices; ..\..\..\..\../platform/devices/MKL03Z4/include; ..\..\..\..\../platform/devices/MKL03Z4/startup; ..\..\..\..\../platform/hal/inc; ..\..\..\..\../platform/drivers/inc; ..\..\..\..\../platform/system/inc; ../../..; ../board; ..\..\..\..\../platform/drivers/src/adc16; ..\..\..\..\../platform/drivers/src/cmp; ..\..\..\..\../platform/drivers/src/gpio; ..\..\..\..\../platform/drivers/src/i2c; ..\..\..\..\../platform/drivers/src/lptmr; ..\..\..\..\../platform/drivers/src/lpuart; ..\..\..\..\../platform/drivers/src/rtc; ..\..\..\..\../platform/drivers/src/spi; ..\..\..\..\../platform/drivers/src/tpm; ..\..\..\..\../platform/drivers/src/vref; ..\..\..\..\../platform/drivers/src/cop
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: IOUART_example.out
  ILINK.IlinkIcfFile: ..\..\..\..\../platform/devices/MKL03Z4/linker/iar/MKL03Z32xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\../lib/ksdk_platform_lib/iar/KL03Z4/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL03Z32VFK4; FRDM_KL03Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group board
    ../board/: board.c board.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
    ../: hardware_init.c
  group sources
    ../: fsl_iouart_driver.c fsl_iouart_driver.h fsl_iouart_irq.c main.c
  group startup
    ../../../../../platform/devices/: startup.c startup.h
    ../../../../../platform/devices/MKL03Z4/startup/iar/: startup_MKL03Z4.s
    ../../../../../platform/devices/MKL03Z4/startup/: system_MKL03Z4.c system_MKL03Z4.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c
    ../../../../../platform/utilities/inc/: fsl_debug_console.h print_scan.h
